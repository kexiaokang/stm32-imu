/*
 * W9：C 端的随机森林推理
 * =====================================================================
 * 这个文件里只有两个函数，加起来不到 30 行。
 *
 * 它是整个部署的"心脏"：板子上真正跑的，就是这两个函数。
 *
 * 为什么要这样做（一句话）：
 *   板子上没有 Python，跑不了 sklearn；
 *   但随机森林的本质只是"一堆阈值比较"，把树拍平成表格后，
 *   一个 while 循环就能走完，不需要任何机器学习库。
 *
 * 编译运行（在 F:\interesting\stm_project\chuanganqi\firmware 下）：
 *     .\build.bat
 */

#include "predict.h"

/* ---------------------------------------------------------------------
 * 函数 1：走一棵树，把这个叶子给出的 5 类概率累加到 out 上。
 *
 * 参数：
 *   t    —— 一棵树
 *   x    —— 19 维特征（x[0]..x[18]）
 *   out  —— 长度 5 的累加器，由调用者负责清零
 *
 * 逻辑就是三步：
 *   ① 从根节点开始
 *   ② 只要不是叶子，就比较一次、往下走一步
 *   ③ 走到叶子，把这一类的 5 个概率加上去
 *
 * 为什么叶子用 "left == -1" 判断：
 *   导出时约定好了——叶子没有孩子，所以 left 填 -1。
 *   内部节点一定有两个孩子，left 不会等于 -1。
 *   （C 语言里没有"-1 号节点"，所以这个值可以安全地当"没有"来用。）
 *
 * 为什么要 `<=` 走左边：
 *   必须和 sklearn 训练时一模一样。sklearn 的规则就是
 *   "特征值 <= 阈值 去左子树"，写成 `<` 会在阈值刚好相等时走错。
 *   这类"差一个等号"的 bug 在浮点数据上几乎查不出来，所以照抄。
 * ------------------------------------------------------------------- */
void tree_predict(const Tree *t, const float *x, float *out)
{
    int node = t->root;                     /* ① 从根开始（根就是 0 号节点） */

    while (t->nodes[node].left != -1) {     /* ② 只要还有孩子，就继续往下走 */
        const Node *n = &t->nodes[node];    /*    先把当前节点取出来，少写几次 t->nodes */

        if (x[n->feature] <= n->threshold)  /*    拿"第 feature 维特征"和阈值比 */
            node = n->left;                 /*    小于等于 → 走左边 */
        else
            node = n->right;                /*    否则     → 走右边 */
    }

    for (int c = 0; c < N_CLASSES; c++)     /* ③ 到叶子了，把 5 类概率加上去 */
        out[c] += t->nodes[node].prob[c];
}

/* ---------------------------------------------------------------------
 * 函数 2：走完整片森林（n_trees 棵），返回最可能的类别。
 *
 * 逻辑：
 *   ① 准备 5 个桶（sum[0..4]），清零
 *   ② 每棵树各走一遍，把自己的概率倒进桶里
 *   ③ 哪个桶里的数字最大，就返回哪个类别
 *
 * 为什么不用除以 n_trees：
 *   5 个数同时除以同一个正数，最大的那个还是最大的。
 *   除以 n_trees 只是为了得到"真正的概率"，对判类别没有影响，
 *   少一次除法，板子上就少一点计算。
 *
 * 为什么不是"投票，少数服从多数"：
 *   sklearn 的 predict 算的是 predict_proba 的 argmax，
 *   也就是"概率求平均"，不是"票数求最多"。
 *   一棵很有把握的树（概率 [0.99, 0.01]）应该比一棵拿不准的树
 *   （[0.51, 0.49]）权重更大，投票法会把这个信息丢掉。
 * ------------------------------------------------------------------- */
int forest_predict(const Forest *f, const float *x)
{
    float sum[N_CLASSES] = {0.0f};          /* ① 5 个桶，全清零 */

    for (int i = 0; i < f->n_trees; i++)    /* ② 每棵树挨个走一遍 */
        tree_predict(&f->trees[i], x, sum);

    int best = 0;                           /* ③ 先假设 0 号桶最大 */
    for (int c = 1; c < N_CLASSES; c++)     /*    再和后面 4 个比一遍 */
        if (sum[c] > sum[best])
            best = c;

    return best;
}
